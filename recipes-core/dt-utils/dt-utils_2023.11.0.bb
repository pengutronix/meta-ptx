require dt-utils.inc

SRC_URI[md5sum] = "4aa4ef310c76a2baa5df62254f0b7453"
SRC_URI[sha256sum] = "d224d941c076c143f43d59cd7c6e1c522926064a31ac34a67720632ddecb6b53"

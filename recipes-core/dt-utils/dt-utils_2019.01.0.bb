require dt-utils.inc

SRC_URI[md5sum] = "d83ebf99b07fa4516aeaa329afb2a6eb"
SRC_URI[sha256sum] = "0905e183d82502f8ec6110b340bd8289ee8c0a048f214e50c5643ece352ce92b"

require dt-utils.inc

SRC_URI[md5sum] = "b10ec651cfb241544a2eb23b5a9f156d"
SRC_URI[sha256sum] = "6fa29f2b38251847376bb78c4a2b6cb126f713a1953c189358e98076cea2dbef"

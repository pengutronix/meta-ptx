require dt-utils.inc

SRC_URI[md5sum] = "89d183f21fa76d4048a92bf638672442"
SRC_URI[sha256sum] = "72415ebab43e76e625b24ffcf6477e0fd62f0e4c1f838c3bad48ee8b3b49fc8c"

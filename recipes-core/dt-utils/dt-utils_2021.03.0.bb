require dt-utils.inc

SRC_URI[md5sum] = "acf0b5e3b18e40e6172b67fbad2e52fb"
SRC_URI[sha256sum] = "36a56924e356250988315cd8761fde52832e6d4934323aca2827ff93fa12907f"

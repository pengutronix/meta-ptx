require barebox.inc

SRC_URI[md5sum] = "8286a8ea2cdd88104e5c6762d93d81db"
SRC_URI[sha256sum] = "3876fe49e96eea6ce0fd59119c63f82390d96a435ff86b5010ea8b7cc10be2a4"

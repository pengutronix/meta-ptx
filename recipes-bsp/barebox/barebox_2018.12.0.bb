require barebox.inc

SRC_URI[md5sum] = "f84d7d3562055c80c3eedce0b14d4a0d"
SRC_URI[sha256sum] = "fd95c8f7cc325d2be5832666d6c9f34fc60040f3a58981212ffeb9e9d991a298"

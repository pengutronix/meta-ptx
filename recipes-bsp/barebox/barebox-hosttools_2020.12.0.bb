# Copyright (C) 2020 Roland Hieber, Pengutronix <rhi@pengutronix.de>
# Released under the MIT license (see COPYING.MIT for the terms)
require barebox-hosttools.inc

SRC_URI[sha1sum] = "26473d4eae6d3da7a2883dbd59795e5338ec8ddb"

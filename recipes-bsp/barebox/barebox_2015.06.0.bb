require barebox.inc

SRC_URI[md5sum] = "481756e428b0516e5737c487f557d693"
SRC_URI[sha256sum] = "77f94a6ee20e57b25ccdef8bf3cf0d493b6d100efe2a2725dd4a1e4ce36f1404"


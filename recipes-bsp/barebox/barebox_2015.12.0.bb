require barebox.inc

SRC_URI[md5sum] = "1ef8926cd2eadc39ce779b8377e7cfcc"
SRC_URI[sha256sum] = "b0b7df82dafcc7aceeaa6285755855a71f6422c5a278949c717096f4ffd7f315"

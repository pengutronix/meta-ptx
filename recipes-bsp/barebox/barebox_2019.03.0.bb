require barebox.inc

SRC_URI[md5sum] = "0b6fd3f04cb3e26276ae3cc20eed1bd7"
SRC_URI[sha256sum] = "375a3010774cdd5169585d757b64c606288d6fce97f26b0b5f3d47319544b3f0"

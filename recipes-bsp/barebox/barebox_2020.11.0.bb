require barebox.inc

SRC_URI[sha256sum] = "049d2b1b887d0397f4b5390255459fb0240200b06a3276ffaefdeab7fb243554"

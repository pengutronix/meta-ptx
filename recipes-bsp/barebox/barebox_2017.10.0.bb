require barebox.inc

SRC_URI[md5sum] = "cae141fd919810397a7d539959d75aae"
SRC_URI[sha256sum] = "bddcf99afc4a686b1121bda923e8ace0b7089505fbada0572d93b6a601682289"

require barebox.inc

SRC_URI[md5sum] = "a4e0a0143289fd1f223b15ccc82ef29a"
SRC_URI[sha256sum] = "ac82fdf011a968a93e004320308b173d2e9c2f46353aabd5a8cf7141340086cf"

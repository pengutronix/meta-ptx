require barebox.inc

SRC_URI[md5sum] = "3b4f2c72ec3b7cc2f1f294fd2baf0c4d"
SRC_URI[sha256sum] = "f650e15c7a6da8cb779bb1787829fa4184b3189baf604c8af3af4e0deefa5e8e"


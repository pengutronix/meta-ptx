require barebox.inc

SRC_URI[sha256sum] = "de55f6bc7572d62e7008799595eb38059dd1acab4f0e5866fa220a9c7104a636"

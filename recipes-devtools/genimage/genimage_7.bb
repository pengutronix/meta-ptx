require genimage.inc
PR = "1"

SRC_URI[md5sum] = "1eb3e6b79e796b85ce7f2186ce298180"
SRC_URI[sha256sum] = "7366dcfe4c542298ffe8a6c8d3551b1c3a84e25bfbb76ca75b9692e974f4534a"

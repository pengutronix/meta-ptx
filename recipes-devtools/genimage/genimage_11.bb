require genimage.inc

SRC_URI[md5sum] = "5db95026ff8aedcbcf7804098f685c7b"
SRC_URI[sha256sum] = "2ee024bfb2ec157651b86f3365d138ee013dcc48277d86e1eed6f3285a67b532"

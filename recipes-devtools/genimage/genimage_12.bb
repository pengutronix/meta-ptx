require genimage.inc

SRC_URI[md5sum] = "dc511f39fa1b1627e4a8a977914a4798"
SRC_URI[sha256sum] = "2e9b43d1288f4e216d6c79de2a0c53ce1bd41f93cec750d8ab057aa2d0b0ee4a"

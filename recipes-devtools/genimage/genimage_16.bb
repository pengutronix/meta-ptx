require genimage.inc

SRC_URI[sha256sum] = "869f9662d3b778c69b1d1fe70df658e1c9e90aeda26abb753f6fe55e8b0c6e73"

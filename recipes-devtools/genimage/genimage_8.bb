require genimage.inc
PR = "1"

SRC_URI[md5sum] = "506a0cd6722431af87ef7cfe437662cc"
SRC_URI[sha256sum] = "363b2222b8036eca927c464994e7a877539adc3ea9ba895c1e2186f0589fafbf"

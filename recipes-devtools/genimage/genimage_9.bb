require genimage.inc
PR = "1"

SRC_URI[md5sum] = "5ad1f651ea9b5678d55c18c693c73e7d"
SRC_URI[sha256sum] = "69f35af7edf6f4dbdac7a18ddc69dcf38c501e43d8b50c524555754c51479078"

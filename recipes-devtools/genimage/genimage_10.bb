require genimage.inc

SRC_URI[md5sum] = "7ac961222a7aa04f43e3bf3fc387d501"
SRC_URI[sha256sum] = "5a36b2c1387007c2d6535a722ee257a387d0913bddcf8a94d460e6acd4d01859"

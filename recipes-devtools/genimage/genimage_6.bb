require genimage.inc
PR = "1"

SRC_URI[md5sum] = "1bc6403087adc872f5d867ccf99f108b"
SRC_URI[sha256sum] = "024e85da0fd8e1522ac244212e834aa427c6273c36efadd7a3fe7809751d4482"

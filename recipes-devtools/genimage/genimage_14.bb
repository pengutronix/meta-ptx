require genimage.inc

SRC_URI[sha256sum] = "9d1d53b33309fe24ea367ea057eb689bdb8ea33cb99d796de31127ca44ccf44c"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://ubinize-Always-return-error-code-at-least-1-in-case-.patch"
